# Keil uVision project IUD.uvproj, settings and files
target IUD3 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: IUD3 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F4XX
  c include: ..\;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\CMSIS\ST\STM32F4xx\Include;..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\Utilities\STM32F4-Discovery;..\..\..\..\Libraries\FreeRTOS\FreeRTOSv10.2.1\FreeRTOS\Source\include;..\..\..\..\Libraries\FreeRTOS\FreeRTOSv10.2.1\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\Libraries\FreeRTOS\FreeRTOSv10.2.1\FreeRTOS\Source\portable\MemMang;..\..\..\..\Libraries\FreeRTOS\FreeRTOSv10.2.1\FreeRTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../: main.c stm32f4xx_it.c system_stm32f4xx.c FreeRTOSConfig.h usart1.c task_manager.c led_status.c user_communication.c data_wearhouse.h pitch_catch.c dsp.c
  group STM32F4-Discovery
    ../../../../Utilities/STM32F4-Discovery/: stm32f4_discovery.c
  group STM32F4xx_StdPeriph_Driver
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c misc.c stm32f4xx_gpio.c stm32f4xx_syscfg.c stm32f4xx_exti.c stm32f4xx_dma.c stm32f4xx_adc.c stm32f4xx_usart.c stm32f4xx_dac.c stm32f4xx_tim.c
  group MDK-ARM
    ../../../../Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group freertos
    ../../../../Libraries/FreeRTOS/FreeRTOSv10.2.1/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../Libraries/FreeRTOS/FreeRTOSv10.2.1/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../Libraries/FreeRTOS/FreeRTOSv10.2.1/FreeRTOS/Source/portable/MemMang/: heap_2.c
